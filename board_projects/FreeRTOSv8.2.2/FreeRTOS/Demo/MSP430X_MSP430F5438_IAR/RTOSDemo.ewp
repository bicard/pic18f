# IAR project RTOSDemo.ewp, settings and files
configuration Debug_Large_Data_Model (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xllff.h
  General.OGChipSelectMenu: MSP430F5438A MSP430F5438A
  General.GStackSize2: 160
  General.GHeapSize2: 4
  General.RadioHeapSizeType: 0
  ICC430.CCDiagSuppress: Pa082
  ICC430.newCCIncludePaths: F5XX_6XX_Core_Lib; MSP-EXP430F5438_HAL; UserExperienceDemo; ..\Common\include; ..\..\Source\include; ..\..\Source\portable\IAR\MSP430X; $PROJ_DIR$
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  A430.ADefines: __DATA_MODEL_LARGE__
  A430.AUserIncludes: $PROJ_DIR$; ..\..\Source\portable\IAR\MSP430X
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f5438a.xcl
  XLINK.XlinkStackSize: 1
configuration Release_Large_Data_Model (MSP430, debug)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xlff.h
  General.GHeapSize2: 160
  ICC430.CCOptLevel: 3
  XLINK.XclFile: lnk430F5438A_mod.xcl
configuration Debug_Small_Data_Model (MSP430, debug)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsff.h
  General.GHeapSize2: 160
  A430.ADefines: __DATA_MODEL_SMALL__
  XLINK.XclFile: lnk430F5438A_mod.xcl
configuration Debug_Medium_Data_Model (MSP430, debug)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xlff.h
  A430.ADefines: __DATA_MODEL_MEDIUM__
  XLINK.XclFile: lnk430F5438A_mod.xcl
  group (top)
    ./: lnk430F5438A_mod.xcl low_level_init.c main.c ParTest.c RegTest.s43 RunTimeStatsConfig.c serial.c
  group F5XX_6XX_Core_Lib
    F5XX_6XX_Core_Lib/: HAL_PMM.c hal_UCS.c
  group FreeRTOS_Source
    ../../Source/: list.c queue.c tasks.c
  group FreeRTOS_Source/Portable
    ../../Source/portable/MemMang/: heap_1.c
    ../../Source/portable/IAR/MSP430X/: port.c portext.s43
  group MSP-EXP430F5438_HAL
    MSP-EXP430F5438_HAL/: hal_board.c hal_buttons.c hal_lcd.c hal_lcd_fonts.c hal_MSP-EXP430F5438.h
  group Standard_Demo_Tasks
    ../Common/Minimal/: comtest.c dynamic.c GenQTest.c
