#include P18F4520.inc

	ORG 0x0

	CLRF PCLATH
	GOTO START

	ORG 0X30
START  
	MOVLW 0x20
	MOVWF TXSTA

	BSF TXSTA, BRGH
	MOVLW 0x81
	MOVWF SPBRG

	BCF TRISC, TX
	BSF RCSTA, SPEN

	MOVLW 0x00
	MOVWF TBLPTRL
	MOVWF TBLPTRU
	MOVLW 0x04
	MOVWF TBLPTRH
	
AGAIN
	TBLRD*+
	MOVF TABLAT, W
	BZ EXIT

L1	BTFSS PIR1, TXIF
	BRA L1
	MOVWF TXREG
	BRA AGAIN

EXIT 
L2	BTFSS PIR1, TXIF
	BRA L2
	MOVLW d'10'
	MOVWF TXREG
	GOTO $

ORG 0x400
STRING  DB "Hello..."
STRING2 DB "Welcome to BICARD!", 0

	END